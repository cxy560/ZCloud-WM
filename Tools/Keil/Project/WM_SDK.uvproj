# Keil uVision project WM_SDK.uvproj, settings and files
target WM_SDK (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: WM_SDK +hex
  AfterMake: fromelf .\objs\WM_SDK.axf --bin -o ..\..\..\Bin\WM_SDK.bin
  AfterMake: createimg.bat
  c flags: Optim=3 wLevel=2
  c define: ZC_MODULE_VERSION=0 ZC_MODULE_TYPE=1
  c misc: --c99 --gnu
  c include: ..\..\..\Src\Drivers;..\..\..\Src\Drivers\dma;..\..\..\Src\Drivers\efuse;..\..\..\Src\Drivers\flash;..\..\..\Src\Drivers\gpio;..\..\..\Src\Drivers\hspi;..\..\..\Src\Drivers\litepoint;..\..\..\Src\Drivers\spi;..\..\..\Src\Drivers\timer;..\..\..\Src\Drivers\uart;..\..\..\Src\Drivers\watchdog;..\..\..\Src\Misc;..\..\..\Src\Network\lwip1.4.1;..\..\..\Src\Network\lwip1.4.1\include;..\..\..\Src\Network\lwip1.4.1\include\arch;..\..\..\Src\Network\lwip1.4.1\include\ipv4;..\..\..\Src\Network\lwip1.4.1\include\ipv4\lwip;..\..\..\Src\Network\lwip1.4.1\include\lwip;..\..\..\Src\Network\lwip1.4.1\include\netif;..\..\..\Src\OS\uCOS-II\ports;..\..\..\Src\OS\uCOS-II\source;..\..\..\Src\Wlan\Driver;..\..\..\Src\Wlan\Supplicant;..\..\..\Include;..\..\..\Src\Inc;..\..\..\Src\Sys;..\..\..\Src\Network\api;..\..\..\App\wm_atcmd;..\..\..\App\demo;..\..\..\Src\Common\Params;..\..\..\Src\Drivers\litepoint;..\..\..\App\dhcpserver;..\..\..\App\dnsserver;..\..\..\App\matrixssl;..\..\..\App\matrixssl\crypto;..\..\..\App\web;..\..\..\Src\OS\RTOS\include;..\..\..\App\cloud;..\..\..\App\cJSON;..\..\..\App\Adapter;..\..\..\App\Adapter\AC\inc;..\..\..\App\Adapter\aes;..\..\..\App\Adapter\ZC\inc\tropicssl;..\..\..\App\Adapter\ZC\inc\zc
  asm include: ..\..\..\Include;..\..\..\Src\OS\RTOS\include
  memory RVCT6: RAM 0x0 size 0x60000
  scatter file: ..\tl6_sdk.sct
  link misc: --entry=start.o(RESET)
  group App/Demo
    ../../../App/demo/: wm_connect_net_demo.c wm_crypt_demo.c wm_demo_console_task.c wm_flash_demo.c wm_gpio_demo.c wm_http_demo.c wm_http_fwup.c wm_master_spi_demo.c wm_mcast_demo.c wm_raw_socket_client_demo.c wm_raw_socket_server_demo.c wm_slave_spi_demo.c wm_socket_client_demo.c wm_socket_fwup.c wm_socket_fwup_demo.c wm_socket_server_demo.c wm_socket_server_sel_demo.c wm_softap_demo.c wm_uart_demo.c wm_wps_demo.c wm_adc_demo.c wm_i2c_demo.c wm_pwm_demo.c wm_ntp_demo.c wm_dlna_mediarender_demo_vs1053.c Wm_cloud_demo.c
  group App/DhcpServer
    ../../../App/dhcpserver/: dhcp_server.c
  group App/DnsServer
    ../../../App/dnsserver/: dns_server.c
  group App/httpClient
    ../../../App/httpclient/: HTTPClient.c HTTPClientAuth.c HTTPClientString.c HTTPClientWrapper.c wm_httpclient_task.c
  group App/wm_atcmd
    ../../../App/wm_atcmd/: wm_cmdp.c wm_cmdp_at.c wm_cmdp_hostif.c wm_cmdp_ri.c wm_hspi_task.c wm_uart_task.c wm_uart_timer.c wm_cmdp_oneshot_task.c
  group App/oneshot
    ../../../App/oneshotconfig/: wm_wifi_oneshot.c
  group App/matrixssl/core
    ../../../App/matrixssl/core/: corelib.c osdep.c
  group App/matrixssl/crypto/digest
    ../../../App/matrixssl/crypto/digest/: hmac.c md2.c md4.c sha224.c sha384.c sha512.c
  group App/matrixssl/crypto/keyformat
    ../../../App/matrixssl/crypto/keyformat/: asn1.c base64.c x509.c
  group App/matrixssl/crypto/math
    ../../../App/matrixssl/crypto/math/: pstm_mul_comba.c
  group App/matrixssl/crypto/prng
    ../../../App/matrixssl/crypto/prng/: prng.c yarrow.c
  group App/matrixssl/crypto/pubkey
    ../../../App/matrixssl/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c rsa.c
  group App/matrixssl/crypto/symmetric
    ../../../App/matrixssl/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
  group App/matrixssl
    ../../../App/matrixssl/: prf.c psk.c sslDecode.c sslEncode.c sslv3.c tls.c cipherSuite.c hsHash.c matrixssl.c matrixsslApi.c
  group App/Expat2.1.0
    ../../../App/Expat2.1.0/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
  group App/libjson0.8
    ../../../App/libjson0.8/: json.c
  group App/sxmlc4.0.5
    ../../../App/sxmlc4.0.5/: sxmlc.c sxmlsearch.c sxmlutils.c
  group App/web
    ../../../App/web/: httpd.c web.c fs.c
  group App/cJSON
    ../../../App/cJSON/: cJSON.c
  group App/cloud
    ../../../App/cloud/: wm_cloud_server.c wm_task.c
  group App/cloud/jd
    ../../../App/cloud/jd/: jd_cloud.c
  group App/ntp
    ../../../App/ntp/: ntp_client.c
  group App/main
    ../../../App/: main.c wm_main.c
  group Include
    ../../../Include/: list.h wm_crypto.h wm_dma.h wm_flash.h wm_fls_gd25qxx.h wm_gpio.h wm_hostspi.h wm_hspi.h wm_http_client.h wm_ieee80211.h wm_include.h wm_os.h wm_regs.h wm_socket.h wm_sockets.h wm_timer.h wm_type_def.h wm_uart.h wm_wifi.h wm_wifi_oneshot.h
  group Src/os/os_ports
    ../../../Src/OS/os_ports/: clock.c
  group Src/ucosII/source
    ../../../Src/OS/uCOS-II/source/: ucos_ii.c
  group Src/ucosII/ports
    ../../../Src/OS/uCOS-II/ports/: os_cpu_c.c os_cpu_a.s
  group Src/rtos/source
    ../../../Src/OS/RTOS/source/: croutine.c heap_2.c heap_3.c list.c queue.c rtostimers.c tasks.c
  group Src/rtos/ports
    ../../../Src/OS/RTOS/ports/: port.c portASM.s
  group Src/Drivers/spi
    ../../../Src/Drivers/spi/: wm_hostspi.c
  group Src/Drivers/timer
    ../../../Src/Drivers/timer/: wm_timer.c
  group Src/Drivers/uart
    ../../../Src/Drivers/uart/: wm_uart.c
  group Src/Drivers/dma
    ../../../Src/Drivers/dma/: wm_dma.c
  group Src/Drivers/efuse
    ../../../Src/Drivers/efuse/: wm_efuse.c
  group Src/Drivers/flash
    ../../../Src/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
  group Src/Drivers/gpio
    ../../../Src/Drivers/gpio/: wm_gpio.c
  group Src/Drivers/hspi
    ../../../Src/Drivers/hspi/: wm_hspi.c
  group Src/Drivers/cpu
    ../../../Src/Drivers/cpu/: wm_cpu.c
  group Src/Drivers/irq
    ../../../Src/Drivers/irq/: wm_irq.c
  group Src/Drivers/i2c
    ../../../Src/Drivers/i2c/: wm_i2c.c
  group Src/Drivers/adc
    ../../../Src/Drivers/adc/: wm_adc.c
  group Src/Drivers/pwm
    ../../../Src/Drivers/pwm/: wm_pwm.c
  group Src/Drivers/rtc
    ../../../Src/Drivers/rtc/: wm_rtc.c
  group Src/Drivers/VS10XX
    ../../../Src/Drivers/VS10XX/: VS10XX.c
  group Src/network/api
    ../../../Src/Network/api/: tls_sockets.c tls_netconn.c
  group Src/Network/lwip1.4.1/api
    ../../../Src/Network/lwip1.4.1/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
  group Src/Network/lwip1.4.1/core
    ../../../Src/Network/lwip1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Src/Network/lwip1.4.1/core/ipv4
    ../../../Src/Network/lwip1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Src/Network/lwip1.4.1/netif
    ../../../Src/Network/lwip1.4.1/netif/: etharp.c ethernetif.c
  group Src/Network/lwip1.4.1
    ../../../Src/Network/lwip1.4.1/: ethernet.c sys_arch.c
  group Src/Inc
    ../../../Src/Inc/: bitops.h tls_common.h tls_ieee80211.h tls_sys.h tls_wireless.h utils.h
  group Src/Boot
    ../../../Src/Boot/: retarget.c mpu.s start.s
  group Src/Sys
    ../../../Src/Sys/: tls_sys.c
  group Src/common/mem
    ../../../Src/Common/mem/: wm_mem.c
  group Src/common/utils
    ../../../Src/Common/utils/: utils.c
  group Src/common/fwup
    ../../../Src/Common/fwup/: wm_fwup.c
  group Wifi/Lib
    ../../../Lib/KEIL/: wifi.lib
  group user
    ../../../App/user/: user_flash.c user_main.c user_spi.c
  group App/Adapter
    ../../../App/Adapter/: zc_hf_adpter.c
    ../../../App/Adapter/ZC/: crc.c
    ../../../App/Adapter/ZC/src/zc/: zc_bc.c zc_client_manager.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_moudle_manager.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
    ../../../App/Adapter/ZC/src/tropicssl/: bignum.c rsa2.c
    ../../../App/Adapter/aes/: aes_cbc.c aes_core.c
    ../../../App/Adapter/AC/src/: ac_api.c ac_hal.c
